# Keil uVision project ZLJN.uvproj, settings and files
target ZLJN (MCS-51)
  device: STC8G2K64S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x07FF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: ZLJN +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Libraries\libraries;..\Libraries\seekfree_libraries;..\Libraries\seekfree_peripheral;..\USER\inc;..\USER\src;..\Libraries\Control
  group startup
    ../Libraries/libraries/: board.c board.h common.c common.h STC8Gxx.h
  group seekfree_libraries
    ../Libraries/seekfree_libraries/: key.c key.h all_init.c all_init.h zf_adc.c zf_adc.h zf_delay.c zf_delay.h zf_eeprom.c zf_eeprom.h zf_exti.c zf_exti.h zf_gpio.c zf_gpio.h zf_iic.c zf_iic.h zf_nvic.c zf_nvic.h zf_pca_delay.c zf_pca_delay.h zf_pca_pit.c zf_pca_pit.h zf_pwm.c zf_pwm.h zf_spi.c zf_spi.h zf_tim.c zf_tim.h zf_uart.c zf_uart.h
  group seekfree_peripheral
    ../Libraries/seekfree_peripheral/: headfile.h SEEKFREE_18TFT.c SEEKFREE_18TFT.h SEEKFREE_ABSOLUTE_ENCODER.c SEEKFREE_ABSOLUTE_ENCODER.h SEEKFREE_FONT.c SEEKFREE_FONT.h SEEKFREE_ICM20602.c SEEKFREE_ICM20602.h SEEKFREE_IIC.c SEEKFREE_IIC.h SEEKFREE_OLED.c SEEKFREE_OLED.h SEEKFREE_TSL1401.c SEEKFREE_TSL1401.h SEEKFREE_VIRSCO.c SEEKFREE_VIRSCO.h SEEKFREE_WIRELESS.c SEEKFREE_WIRELESS.h
    ../Libraries/libraries/: SEEKFREE_PRINTF.c SEEKFREE_PRINTF.h
  group user_c
    ../USER/src/: isr.c main.c
    ../Libraries/Control/: Control.c Control.h test.c test.h ccd_judge.c yuansu.c speedcontrol.c
    $TC_ROOT$/../../学习/智能车/破浪2.0/直立节能2/直立节能/ZLJN/Libraries/Control/: speedcontrol.h
  group user_h
    ../USER/inc/: isr.h
